# Keil uVision project new.uvprojx, settings and files
target new (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F030R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: new
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F051
  c include: ..\CMSIS\Include;..\CMSIS\Device\ST\STM32F0xx\Include;..\lib\inc;..\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group inc
    ../inc/: stm32f0xx_conf.h
  group src
    ../src/: main.c stm32f0xx_it.c system_stm32f0xx.c
  group lib
    ../lib/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c
  group CMSIS
    ../CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f030.s
